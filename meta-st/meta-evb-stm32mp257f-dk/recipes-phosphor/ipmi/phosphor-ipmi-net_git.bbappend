FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

DEFAULT_RMCPP_IFACE = "eth0"
